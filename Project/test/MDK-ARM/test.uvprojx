# Keil uVision project test.uvprojx, settings and files
target test (ARM-ADS)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.1.0
  cpu: IROM(0x08000000,0x080000) IRAM(0x20000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,__FPU_PRESENT
  c include: ..\..\..\Library\Firmware\CMSIS;..\..\..\Library\Firmware\CMSIS\GD\GD32F30x\Include;..\..\..\Library\Firmware\GD32F30x_standard_peripheral\Include;..\..\..\Library\Utilities;..\;..\bsp\key;..\bsp\led;..\source;..\osal\FreeRTOS\kernel\include;..\osal\FreeRTOS\kernel\portable\RVDS\ARM_CM4F;..\osal\FreeRTOS;..\osal;..\source\system;..\source\output;..\source\input\sensor;..\source\common;..\bsp\i2c;..\bsp\delay;..\source\network;..\RTT\Config;..\RTT\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../: main.c gd32f30x_it.c systick.c
  group CMSIS
    ../../../Library/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../../../Library/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group GD32F30x_EVAL
    ../../../Library/Utilities/: gd32f303e_eval.c
  group Startup
    ../../../Library/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group Doc
    ../: readme.txt
  group BSP
    ../bsp/key/: key.c
    ../bsp/led/: led.c
    ../bsp/i2c/: i2c.c
    ../bsp/delay/: delay.c
  group Source
    ../source/system/: system.c test_task.c
    ../source/output/: uart_printf.c
    ../source/common/: timer.c kfifo.c util.c
  group Osal
    ../osal/: osal.c
    ../osal/FreeRTOS/kernel/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../osal/FreeRTOS/kernel/portable/RVDS/ARM_CM4F/: port.c
    ../osal/FreeRTOS/kernel/portable/MemMang/: heap_4.c
  group RTT
    ../RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
